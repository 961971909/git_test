# Keil uVision project 72_Multi.uvprojx, settings and files
target LCD_Mult_7_103 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PD354-LAS3Y-R-H-20200301 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,IWDG_DEBUG,_GUILCD_,_LEDHarm_
  c misc: --c99
  c include: ..\src\User\Include;..\src\Libraries\CMSIS\Include;..\src\Libraries\CMSIS\STM32F0xx\Include;..\src\Libraries\StdPeriph_Lib\inc;..\src\Bsp;..\src\Driver;..\src\pt;..\src\User;..\src\User\Pub;..\src\User\Task;..\src\User\Mem
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../src/BSP/: system_stm32f10x.c
    ../src/Libraries/CMSIS/STM32F0xx/Source/: startup_stm32f10x_md.s
    ../src/Libraries/CMSIS/Include/: core_cm3.c
  group User_Task
    ../src/User/Task/: taskGUI.c taskExtra.c taskProtect.c taskRS232.c taskLedGUI.c
  group Driver
    ../src/Driver/: drvSerial.c bsp_LCD.c bsp_RN8302B.c drvFram.c param.c drvLED.c
  group User
    ../src/User/: sysMain.c
  group Bsp
    ../src/Bsp/: Bsp.c
    ../src/BSP/: stm32f10x_it.c
  group StdPeriph_Lib
    ../src/Libraries/StdPeriph_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User_Mem
    ../src/User/Mem/: MemDataOperate.c
  group pt
    ../src/pt/: pt.c pt_sem.c pt_timer.c SCH.c
target LED_Mult_7_103 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: as above
  output: PD354-LAS3N-R-190318 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,IWDG_DEBUG,_GUILED_,_LEDHarm_
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
